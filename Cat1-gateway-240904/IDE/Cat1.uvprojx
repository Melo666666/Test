# Keil uVision project Cat1.uvprojx, settings and files
target V1.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F103RG GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cat1_V1009_20241106 +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1
  c define: NDEBUG,
  c include: ..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\freemodbus-v1.6\modbus\include;..\freemodbus-v1.6\portable;..\freemodbus-v1.6\modbus\rtu;..\BSP;..\APP;..\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS_STM32F103C8;..\ModbusMaster
  library: MicroLIB
  memory RVCT4: ROM 0x8002400 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group freertos
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group freemodbus
    ../freemodbus-v1.6/modbus/: mb.c
    ../freemodbus-v1.6/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../freemodbus-v1.6/modbus/rtu/: mbcrc.c mbrtu.c
    ../freemodbus-v1.6/portable/: portevent.c portserial.c porttimer.c
  group application
    ../APP/: main.c ledThread.c modbusCB.c airSensor.c cfgThread.c devCom.c wifi232.c netThread.c clm920.c
  group bsp
    ../BSP/: bspLed.c NVIC.c bspTimer.c bspIWDG.c bsp_InternalFlash.c bspAirCom.c bspRtc.c bspDevCom.c bspDevCtl.c bspWifi232b2.c bspClm920.c bspNetCom.c bspPublic.c DevUpDateCode.c bspDevTag.h
  group driver
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS_STM32F103C8/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_xl.s
  group readme
    ../Doc/: readme.txt
